# IAR project hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_MODEM_LORA; STM32F10X_HD; USE_STDPERIPH_DRIVER; USE_STM3210E_EVAL; USE_BAND_868
  ICCARM.CCDiagSuppress: Pa050, Pa089
  ICCARM.CCIncludePath2: ..\..\src\boards\mcu\stm32; ..\..\src\boards\Bleeper-76\cmsis; ..\..\src\boards\Bleeper-76; ..\..\src\boards\mcu\stm32; ..\..\src\boards\mcu\stm32\STM32F10x_StdPeriph_Driver\inc; ..\..\src\mac; ..\..\src\radio; ..\..\src\radio\sx1276; ..\..\src\system\; ..\..\src\system\crypto; ..\..\lmic
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hello.hex
  ILINK.IlinkOutputFile: hello.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group lmic
    ../../lmic/: debug.c stm32_eval_spi_flash.c
  group src/boards/Bleeper-76
    ../../src/boards/Bleeper-76/: board.c spi-board.c sx1276-board.c timer-board.c
  group src/boards/Bleeper-76/cmsis
    ../../src/boards/Bleeper-76/cmsis/: system_stm32f10x.c
  group src/boards/Bleeper-76/cmsis/arm-gcc
    ../../src/boards/Bleeper-76/cmsis/arm-gcc/: startup_stm32f10x_hd.s
  group src/boards/mcu/stm32
    ../../src/boards/mcu/stm32/: utilities.c
  group src/boards/mcu/stm32/STM32F10x_StdPeriph_Driver/src
    ../../src/boards/mcu/stm32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group src/mac
    ../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group src/radio/sx1276
    ../../src/radio/sx1276/: sx1276.c
  group src/system
    ../../src/system/: delay.c fifo.c gpio.c timer.c uart.c
  group src/system/crypto
    ../../src/system/crypto/: aes.c cmac.c
